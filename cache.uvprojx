# Keil uVision project cache.uvprojx, settings and files
target cache sdram_debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: cache
  group source
    ./: cache.c startup_MIMXRT1052.S
  group doc
    ./: readme.txt
software components: CMSIS:CORE 5.1.1, Board Support:SDK Project Template:project_template 1.0.0, Device:SDK Drivers:cache 2.0.1, Device:SDK Drivers:clock 2.1.0, Device:SDK Drivers:common 2.1.0, Device:SDK Drivers:dmamux 2.0.2, Device:SDK Drivers:edma 2.1.8, Device:SDK Drivers:gpio 2.0.2, Device:SDK Drivers:iomuxc 2.0.0, Device:SDK Drivers:lists 1.0.0, Device:SDK Drivers:lpuart 2.2.7, Device:SDK Drivers:lpuart_adapter 1.0.0, Device:SDK Drivers:semc 2.0.4, Device:SDK Drivers:xip_board 2.0.0, Device:SDK Drivers:xip_device 2.0.0, Device:SDK Utilities:assert 1.0.0, Device:SDK Utilities:debug_console 1.0.0, Device:SDK Utilities:serial_manager 1.0.0, Device:SDK Utilities:serial_manager_uart 1.0.0, Device:Startup:MIMXRT1052_startup 1.0.0
